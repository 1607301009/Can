# Keil uVision project NiRenMCP2515.uvproj, settings and files
target 目标 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: NiRenMCP2515 +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: STARTUP.A51 main.c MCP2515.c UART.c MCP2515.h
